<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>len(constellation.points())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timing_max_dev</value></param>
<param><key>value</key><value>1.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>value</key><value>0.0628</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_bw</value></param>
<param><key>value</key><value>0.0628</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timing_bw</value></param>
<param><key>value</key><value>0.0628</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>11 * int(samples_per_symbol*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation</value></param>
<param><key>value</key><value>digital.bpsk_constellation()</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>sps</key><value>samples_per_symbol</value></param>
<param><key>loop_bw</key><value>timing_bw</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(nfilts,nfilts*samples_per_symbol,1.0,excess_bw,ntaps)</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>max_dev</key><value>timing_max_dev</value></param>
<param><key>osps</key><value>1</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>samps_per_sym</key><value>samples_per_symbol</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>filter_size</key><value>55</value></param>
<param><key>w</key><value>freq_bw</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>0.6e-1</value></param>
<param><key>decay_rate</key><value>1e-3</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
</block>
<block>
<key>ldpc_ece535a_ldpc_decoder_cb</key>
<param><key>id</key><value>ldpc_ece535a_ldpc_decoder_cb_0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>bins</key><value>256</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>xmax</key><value>255</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>ymax</key><value>255</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.4</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>910000000</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>receiver</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ldpc_ece535a_ldpc_decoder_cb_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>ldpc_ece535a_ldpc_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
